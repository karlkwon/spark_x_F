Commit message: Add files via upload
update image & model

File: openmanipulator_sub.URDF (robot description, URDF)
Before this commit: robot openmanipulator, 2 links, 1 joints
Joints:
- joint j1: origin xyz=0 0 0.077 rpy=1.5707963267949 0 0.77 -> xyz=0 0 0.077 rpy=1.5707963267949 0 0
